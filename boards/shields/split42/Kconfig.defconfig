## boards/shields/split42/Kconfig.defconfig
```kconfig
if SHIELD_SPLIT42

config ZMK_KEYBOARD_NAME
	default "Split 42"

config I2C
	default y

config GPIO_PCA95XX
	default y

endif
```
